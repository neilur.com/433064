Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: Project Number
Time: 2023-04-07T14:38:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20211019_1515(x64) - Exporter 20.2.60.15 - Alternate UI 20.2.60.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 07 14:38:50 2023 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\c7e508df-9a2f-4df8-9830-52c09c4cd7c5\74f9249a-374e-41d9-84dc-314751c57bc5\ifc * Database version: 5507 * Database creation date: Fri Apr 07 14:38:50 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 07 14:38:50 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 07 14:38:50 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Awaiting Approval

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding, n/a
LongName: n/a
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 0
